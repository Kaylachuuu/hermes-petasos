# Petasos's login greeting in place of yocto-superbird's.
FILESEXTRAPATHS:prepend := "${THISDIR}/base-files:"
