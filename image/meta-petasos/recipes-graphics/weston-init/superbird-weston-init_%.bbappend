# The boot logo again, behind the kiosk while it loads (image/splash/make.py writes this file).
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
