# Only the wg tool: no wg-quick (bash) or bash completion. systemd-networkd sets up the tunnel.
PACKAGECONFIG = ""
