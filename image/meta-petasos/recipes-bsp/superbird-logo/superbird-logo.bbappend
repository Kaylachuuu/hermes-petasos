# The winged hat boot logo (image/splash/ has the source and make.py, which writes this file).
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
